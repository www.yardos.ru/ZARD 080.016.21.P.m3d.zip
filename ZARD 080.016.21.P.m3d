# KOMPAS-3D part (ZARD 080.016.21.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ЗАРД 080.016.21-ХХ.Р
  ООО "ИК Энерпред-Ярдос"